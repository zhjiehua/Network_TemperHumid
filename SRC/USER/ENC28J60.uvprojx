# Keil uVision project ENC28J60.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ENC28J60 +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\RTC;..\HARDWARE\RTC;..\USMART;..\HARDWARE\SPI;..\uIP-APP;..\uIP-1.0\uip;..\uIP-1.0\apps\webserver;..\HARDWARE\ENC28J60;..\HARDWARE\TIMER;..\HARDWARE\ADC;..\HARDWARE\ITEMP;..\HARDWARE\DM9000A;..\HARDWARE\24CXX;..\HARDWARE\DHT12;..\HARDWARE\WDG;..\uIP-1.0\apps\resolv
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/ITEMP/: tsensor.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/TIMER/: timerx.c
    ../HARDWARE/DM9000A/: dm9k_uip.c dm9000a.c
    ../HARDWARE/ENC28J60/: enc28j60.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/DHT12/: dht12.c myiic.c
    ../HARDWARE/WDG/: wdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_bkp.c stm32f10x_dbgmcu.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_iwdg.c
  group uIP-1.0
    ../uIP-1.0/uip/: psock.c timer.c uip.c uip_arp.c uip-fw.c uiplib.c uip-neighbor.c uip-split.c
  group uIP-APP
    ../uIP-APP/: clock-arch.c tapdev.c tcp_client_demo.c tcp_server_demo.c protocol.c uip_demo.c udp_client_demo.c udp_server_demo.c
    ../uIP-1.0/apps/webserver/: httpd.c httpd-cgi.c httpd-fs.c http-strings.c
    ../uIP-1.0/apps/resolv/: resolv.c
